Commit message: LastUpdate

File: src/mastering_ros_robot_description_pkg-master/urdf/seven_dof_arm.xacro (robot description, xacro)
@@ -84,5 +84,5 @@
 	       <box size="1 1 0.02" />
       </geometry>
-      <material name="Brown" />
+      <material name="Red" />
     </visual>
     <collision>
